File: PowerSupply.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: initial
Parts:
- removed NT1: NetTie_2, NetTie:NetTie-2_SMD_Pad2.0mm, symbol Device:NetTie_2
